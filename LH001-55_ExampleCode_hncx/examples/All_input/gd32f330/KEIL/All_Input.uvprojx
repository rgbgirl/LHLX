# Keil uVision project All_Input.uvprojx, settings and files
target Target 1 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: GD32F330F8 GigaDevice
  pack: GigaDevice.GD32F3x0_DFP.3.0.2
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x02000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: AIN_Isource
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: GD32F330
  c include: ..\..\..\..\lh_lib;..\..\..\..\mcu\gd32f330\lib\inc;..\..\..\..\mcu\gd32f330\port
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group application
    ../: main.c
  group lh_lib
    ../../../../lh_lib/: LH001_55.c
  group mcu_lib
    ../../../../mcu/gd32f330/lib/src/: gd32f3x0_exti.c gd32f3x0_fmc.c gd32f3x0_gpio.c gd32f3x0_spi.c gd32f3x0_syscfg.c gd32f3x0_timer.c gd32f3x0_usart.c
  group port
    ../../../../mcu/gd32f330/port/: spi_port.c uart_print.c
software components: CMSIS:CORE 3.40.0, Device:GD32F3x0_StdPeripherals:MISC 2.0.0, Device:GD32F3x0_StdPeripherals:RCU 2.0.0, Device:GD32F3x0_libopt 2.0.0, Device:Startup 2.0.0
